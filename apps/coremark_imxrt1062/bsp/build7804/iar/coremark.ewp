# IAR project coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: coremark.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; ITERATIONS=40000
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../src; ../../../src; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/drivers; ../../../../../CMSIS/Include; ../../../../../middleware/coremark; ../../../../../platform/drivers/common; ../../../../../platform/drivers/igpio; ../../../../../platform/drivers/iomuxc; ../../../../../platform/drivers/lpuart; ../../../../../platform/drivers/pit; ../../../../../platform/utilities/debug_console; ../../../../../platform/utilities/debug_console/io; ../../../../../platform/utilities/debug_console/log; ../../../../../platform/utilities/debug_console/str
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkOutputFile: coremark_a000.out
  ILINK.IlinkIcfFile: ../../../../../devices/MIMXRT1062/iar/MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group IMXRT1062/bsp
    ../../src/: app.h board.c board.h clock_config.c clock_config.h hapi_irom_clock.c hardware_init.c pin_mux.c pin_mux.h
  group IMXRT1062/coremark_bsp
    ../../../src/: core_portme.c cvt.c ee_printf.c
  group src/middleware/coremark
    ../../../../../middleware/coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group src/platform/driver/clock
    ../../../../../devices/MIMXRT1052/drivers/: fsl_clock.c
  group src/platform/driver/igpio
    ../../../../../platform/drivers/igpio/: fsl_gpio.c fsl_gpio.h
  group src/platform/driver/lpuart
    ../../../../../platform/drivers/lpuart/: fsl_lpuart.c fsl_lpuart.h
  group src/platform/driver/pit
    ../../../../../platform/drivers/pit/: fsl_pit.c fsl_pit.h
  group src/platform/utilities
    ../../../../../platform/utilities/debug_console/: fsl_debug_console.c
    ../../../../../platform/utilities/debug_console/io/: fsl_io.c
    ../../../../../platform/utilities/debug_console/log/: fsl_log.c
    ../../../../../platform/utilities/debug_console/str/: fsl_str.c
  group src/startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
    ../../../../../devices/MIMXRT1062/: system_MIMXRT1062.c system_MIMXRT1062.h
