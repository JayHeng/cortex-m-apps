<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\iar\coremark_pro_core0.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>hello_world_demo_cm33_core0</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>hello_world_demo_cm33_core0</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>hello_world_demo_cm33_core0</project>
                <configuration>flash_debug</configuration>
            </member>
            <member>
                <project>hello_world_demo_cm33_core0</project>
                <configuration>flash_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>release</name>
            <member>
                <project>hello_world_demo_cm33_core0</project>
                <configuration>release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>debug</name>
            <member>
                <project>hello_world_demo_cm33_core0</project>
                <configuration>debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flash_debug</name>
            <member>
                <project>hello_world_demo_cm33_core0</project>
                <configuration>flash_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flash_release</name>
            <member>
                <project>hello_world_demo_cm33_core0</project>
                <configuration>flash_release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
