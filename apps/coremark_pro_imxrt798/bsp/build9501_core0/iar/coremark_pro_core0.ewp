# IAR project coremark_pro_core0.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT798S_M33_0 NXP MIMXRT798S_M33_0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT798SGFOA_cm33_core0; BOOT_HEADER_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../src_core0; ../../../src; ../../../../../devices_v3/MIMXRT798S/drivers; ../../../../../devices_v3/MIMXRT798S/utilities/debug_console_lite; ../../../../../devices_v3/MIMXRT798S; ../../../../../components_v3/uart; ../../../../../components_v3/lists; ../../../../../devices_v3/MIMXRT798S/utilities/str; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: hello_world_demo_cm33_core0.out
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 58
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT798SGFOA_cm33_core0; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT798S/drivers; ../../../../../../devices/MIMXRT798S/utilities/debug_console_lite; ../../../../../../devices/MIMXRT798S; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../flash_config; ../../../../../../devices/MIMXRT798S/utilities/str; ../../../../../../CMSIS/Core/Include
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_flash.icf
configuration release (ARM)
  as the first configuration, except:
  General.CoreVariant: 58
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT798SGFOA_cm33_core0; BOOT_HEADER_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  General.CoreVariant: 58
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT798SGFOA_cm33_core0; BOOT_HEADER_ENABLE=1; NDEBUG; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT798Sxxxx_cm33_core0_flash.icf
  group board
    ../../src_core0/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    ../../../../../components_v3/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    ../../../../../components_v3/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../devices_v3/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core0.h MIMXRT798S_cm33_core0_features.h system_MIMXRT798S_cm33_core0.c system_MIMXRT798S_cm33_core0.h
  group drivers
    ../../../../../devices_v3/MIMXRT798S/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_glikey.c fsl_glikey.h fsl_gpio.c fsl_gpio.h fsl_iopctl.h fsl_lpflexcomm.c fsl_lpflexcomm.h fsl_lpuart.c fsl_lpuart.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_xspi.c fsl_xspi.h
  group source
    ../../src_core0/: hello_world.c
  group startup
    ../../../../../devices_v3/MIMXRT798S/iar/: startup_MIMXRT798S_cm33_core0.s
  group utilities
    ../../../../../devices_v3/MIMXRT798S/utilities/debug_console_lite/: fsl_assert.c fsl_assert.h fsl_debug_console.c fsl_debug_console.h
    ../../../../../devices_v3/MIMXRT798S/utilities/str/: fsl_str.c fsl_str.h
