# IAR project coremark_ek_ra8m1_ep.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA8M1AH Renesas R7FA8M1AH
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 65
  General.FPU2: 7
  ICCARM.CCDefines: _RENESAS_RA_; _RA_CORE=CM85
  ICCARM.IExtraOptions: -f "xcl/rasc_iccarm"
  ICCARM.CCIncludePath2: ../e2studio/ra/arm/CMSIS_6/CMSIS/Core/Include; ../e2studio/ra/fsp/inc; ../e2studio/ra/fsp/inc/api; ../e2studio/ra/fsp/inc/instances; ../e2studio/ra_cfg/fsp_cfg; ../e2studio/ra_cfg/fsp_cfg/bsp; ../e2studio/ra_gen; ../e2studio/src; ../e2studio/src/coremark; ../e2studio/src/coremark/barebones
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _RENESAS_RA_; _RA_CORE=CM85
  AARM.AUserIncludes: ra/arm/CMSIS_6/CMSIS/Core/Include; ra/fsp/inc; ra/fsp/inc/api; ra/fsp/inc/instances; ra_cfg/fsp_cfg; ra_cfg/fsp_cfg/bsp; ra_gen; src
  OBJCOPY.OOCOutputFile: coremark_ek_ra8m1_ep.hex
  ILINK.IlinkOutputFile: coremark_ek_ra8m1_ep.out
  ILINK.IlinkIcfFile: script/fsp.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"; -f "xcl/rasc_ilinkarm"
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RENESAS_RA_; _RA_CORE=CM85
  ICCARM.CCIncludePath2: ra/arm/CMSIS_5/CMSIS/Core/Include; ra/fsp/inc; ra/fsp/inc/api; ra/fsp/inc/instances; ra_cfg/fsp_cfg; ra_cfg/fsp_cfg/bsp; ra_gen; src
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/ra_cfg
    ../e2studio/ra_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_pin_cfg.h
    ../e2studio/ra_cfg/fsp_cfg/: r_gpt_cfg.h r_icu_cfg.h r_ioport_cfg.h r_lpm_cfg.h r_sci_b_uart_cfg.h r_ulpt_cfg.h
  group Flex Software/ra/arm
    ../e2studio/ra/arm/CMSIS_6/CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h armv81m_pac.h armv8m_mpu.h armv8m_pmu.h cmsis_armclang_m.h cmsis_clang_m.h cmsis_gcc_m.h cmsis_iccarm_m.h cmsis_tiarmclang_m.h
    ../e2studio/ra/arm/CMSIS_6/CMSIS/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm52.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h tz_context.h
  group Flex Software/ra/board
    ../e2studio/ra/board/ra8m1_ek/: board.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
  group Flex Software/ra/fsp
    ../e2studio/ra/fsp/src/bsp/mcu/all/: board_sdram.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_macl.c bsp_macl.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_rom_registers.c bsp_sbrk.c bsp_sdram.c bsp_sdram.h bsp_security.c bsp_security.h bsp_tfu.h
    ../e2studio/ra/fsp/inc/api/: bsp_api.h fsp_common_api.h r_external_irq_api.h r_ioport_api.h r_lpm_api.h r_timer_api.h r_transfer_api.h r_uart_api.h
    ../e2studio/ra/fsp/src/bsp/mcu/ra8m1/: bsp_elc.h bsp_feature.h bsp_feature_gen.h bsp_mcu_info.h bsp_override.h
    ../e2studio/ra/fsp/inc/: fsp_features.h fsp_version.h
    ../e2studio/ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R7FA8M1AH.h renesas.h system.h
    ../e2studio/ra/fsp/src/r_gpt/: r_gpt.c
    ../e2studio/ra/fsp/inc/instances/: r_gpt.h r_icu.h r_ioport.h r_lpm.h r_sci_b_uart.h r_ulpt.h
    ../e2studio/ra/fsp/src/r_icu/: r_icu.c
    ../e2studio/ra/fsp/src/r_ioport/: r_ioport.c
    ../e2studio/ra/fsp/src/r_lpm/: r_lpm.c
    ../e2studio/ra/fsp/src/r_sci_b_uart/: r_sci_b_uart.c
    ../e2studio/ra/fsp/src/r_ulpt/: r_ulpt.c
    ../e2studio/ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/ra_gen
    ../e2studio/ra_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/src
    ../e2studio/src/: common_utils.h coremark_ep.c coremark_ep.h gpt_timer.c gpt_timer.h hal_entry.c uart_terminal.c uart_terminal.h ulpt_ep.c ulpt_ep.h
    ../e2studio/src/coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
    ../e2studio/src/coremark/barebones/: core_portme.c core_portme.h cvt.c ee_printf.c
