# IAR project coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; ITERATIONS=40000; COMPILER_VERSION="IAR EWARM v9.10.2"
  ICCARM.CCIncludePath2: ../../src_v2; ../../../src_v2; ../../../../../devices_v2/MIMXRT1052; ../../../../../devices_v2/MIMXRT1052/drivers; ../../../../../devices_v2/MIMXRT1052/utilities/debug_console_lite; ../../../../../components_v2/uart; ../../../../../components_v2/lists; ../../../../../CMSIS/Include; ../../../../../middleware/coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: coremark.out
  ILINK.IlinkIcfFile: ../../../../../devices_v2/MIMXRT1052/iar/MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; ITERATIONS=40000; COMPILER_VERSION="IAR EWARM v9.10.2"
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  OBJCOPY.OOCOutputFile: coremark.srec
  ILINK.IlinkOutputFile: coremark_a000.out
  group IMXRT1052/bsp
    ../../src_v2/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group IMXRT1052/coremark_bsp
    ../../../src_v2/: core_portme.c cvt.c ee_printf.c
  group src/component/lists
    ../../../../../components_v2/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group src/component/uart
    ../../../../../components_v2/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group src/middleware/coremark
    ../../../../../middleware/coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group src/platform/drivers
    ../../../../../devices_v2/MIMXRT1052/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_pit.c fsl_pit.h
  group src/platform/utilities
    ../../../../../devices_v2/MIMXRT1052/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
  group src/startup
    ../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
    ../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
