# IAR project dhrystone.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT685SEVKA; BOOT_HEADER_ENABLE=1; ARM_MATH_CM33; REG=register; NUMBER_OF_RUNS=2000000; CORE_FREQ_MHz=300
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../src; ../../../src; ../../../../../CMSIS/Include; ../../../../../middleware/dhrystone; ../../../../../devices; ../../../../../devices/MIMXRT685S/drivers; ../../../../../devices/MIMXRT685S; ../../../../../devices/MIMXRT685S/utilities/str; ../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: dhrystone.out
  ILINK.IlinkIcfFile: ../../../../../devices/MIMXRT685S/iar/MIMXRT685Sxxxx_ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../devices/MIMXRT685S/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SEVKA; BOOT_HEADER_ENABLE=1; ARM_MATH_CM33; REG=register; NUMBER_OF_RUNS=2000000; CORE_FREQ_MHz=300
  ICCARM.CCIncludePath2: ../../src; ../../../src; ../../../../../CMSIS/Include; ../../../../../middleware/dhrystone; ../../../../../devices; ../../../../../devices/MIMXRT685S/drivers; ../../../../../devices/MIMXRT685S/xip; ../../../../../devices/MIMXRT685S; ../../../../../devices/MIMXRT685S/utilities/str; ../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists
  AARM.ADefines: NDEBUG
  group IMXRT685/bsp
    ../../src/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group IMXRT685/dhrystone_bsp
    ../../../src/: dhry_portme.c dhry_portme.h
  group src
    ../../../src/: dhrystone.c
  group src/component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group src/component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group src/component/uart
    ../../../../../components/uart/: uart.h usart_adapter.c
  group src/middleware/dhrystone
    ../../../../../middleware/dhrystone/: dhry.h dhry_1.c dhry_2.c
  group src/platform/CMSIS
    ../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm33.h mpu_armv7.h mpu_armv8.h tz_context.h
  group src/platform/device
    ../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S.h MIMXRT685S_features.h system_MIMXRT685S.c system_MIMXRT685S.h
  group src/platform/drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_ctimer.c fsl_ctimer.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iopctl.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group src/startup
    ../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S.s
  group src/utilities
    ../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
