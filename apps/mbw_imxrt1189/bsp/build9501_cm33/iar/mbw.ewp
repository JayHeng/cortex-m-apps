# IAR project mbw.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1189CVM8B_cm33; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../src; ../../../src; ../../../../../devices_v3/MIMXRT1189/utilities/debug_console_lite; ../../../../../devices_v3/MIMXRT1189/drivers; ../../../../../devices_v3/MIMXRT1189; ../../../../../components_v3/uart; ../../../../../components_v3/lists; ../../../../../devices_v3/MIMXRT1189/xip; ../../../../../devices_v3/MIMXRT1189/drivers/cm33; ../../../../../components_v3/silicon_id/socs; ../../../../../components_v3/silicon_id; ../../../../../devices_v3/MIMXRT1189/utilities/str; ../../../../../CMSIS/Include; ../../../../../middleware/mbw
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: hello_world_demo_cm33.out
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1189CVM8B_cm33; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group (top)
    ../../../src/: main.c mbw_port.c
  group IMXRT1189/bsp
    ../../src/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group src/component/lists
    ../../../../../components_v3/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group src/component/silicon_id
    ../../../../../components_v3/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
    ../../../../../components_v3/silicon_id/socs/imxrt1180/: fsl_silicon_id_soc.c
    ../../../../../components_v3/silicon_id/socs/: fsl_silicon_id_soc.h
  group src/component/uart
    ../../../../../components_v3/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group src/middleware/mbw
    ../../../../../middleware/mbw/: mbw.c mbw.h mbw_utils.c
  group src/platform/device
    ../../../../../devices_v3/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group src/platform/drivers
    ../../../../../devices_v3/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
    ../../../../../devices_v3/MIMXRT1189/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_ele_base_api.c fsl_ele_base_api.h fsl_iomuxc.h fsl_lpit.c fsl_lpit.h fsl_lpuart.c fsl_lpuart.h fsl_misc.h fsl_pmu.c fsl_pmu.h fsl_rgpio.c fsl_rgpio.h fsl_s3mu.c fsl_s3mu.h
  group src/platform/utilities
    ../../../../../devices_v3/MIMXRT1189/utilities/debug_console_lite/: fsl_assert.c fsl_assert.h fsl_debug_console.c fsl_debug_console.h
    ../../../../../devices_v3/MIMXRT1189/utilities/str/: fsl_str.c fsl_str.h
  group src/startup
    ../../../../../devices_v3/MIMXRT1189/iar/: startup_MIMXRT1189_cm33.s
