# IAR project coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: coremark.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1062DVL6A; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; ITERATIONS=40000
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../src; ../../../src; ../../../../../devices/MIMXRT1062; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/utilities/str; ../../../../../devices/MIMXRT1062/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../CMSIS/Include; ../../../../../middleware/coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: coremark.srec
  ILINK.IlinkOutputFile: coremark_a000.out
  ILINK.IlinkIcfFile: ../../../../../devices/MIMXRT1062/iar/MIMXRT1062xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group IMXRT1062/bsp
    ../../src/: app.h board.c board.h clock_config.c clock_config.h hardware_init.c pin_mux.c pin_mux.h
  group IMXRT1062/coremark_bsp
    ../../../src/: core_portme.c cvt.c ee_printf.c
  group src/component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group src/component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group src/component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group src/middleware/coremark
    ../../../../../middleware/coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group src/platform/drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_pit.c fsl_pit.h
  group src/platform/utilities
    ../../../../../devices/MIMXRT1062/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1062/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
  group src/startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
    ../../../../../devices/MIMXRT1062/: system_MIMXRT1062.c system_MIMXRT1062.h
