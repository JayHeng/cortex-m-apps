# IAR project coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: coremark.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1176DVMAA_cm7; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; ITERATIONS=80000
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../src; ../../../src; ../../../../../devices/MIMXRT1176; ../../../../../devices/MIMXRT1176/drivers; ../../../../../devices/MIMXRT1176/utilities/str; ../../../../../devices/MIMXRT1176/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../CMSIS/Include; ../../../../../middleware/coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: coremark.bin
  postbuild: cmd /c ..\..\..\loader\create_image.bat Release
  ILINK.IlinkIcfFile: ../../../../../devices/MIMXRT1176/iar/MIMXRT1176xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group IMXRT1176/bsp
    ../../src/: app.h board.c board.h clock_config.c clock_config.h hardware_init.c pin_mux.c pin_mux.h
  group IMXRT1176/coremark_bsp
    ../../../src/: core_portme.c cvt.c ee_printf.c
  group src/component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group src/component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group src/component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group src/middleware/coremark
    ../../../../../middleware/coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group src/platform/drivers
    ../../../../../devices/MIMXRT1176/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h
  group src/platform/utilities
    ../../../../../devices/MIMXRT1176/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1176/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1176/utilities/str/: fsl_str.c fsl_str.h
  group src/startup
    ../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
    ../../../../../devices/MIMXRT1176/: system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
