# IAR project coremark_loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: coremark.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 39
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1176DVMAA_cm4
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../launcher; ../../../../../devices/MIMXRT1176; ../../../../../devices/MIMXRT1176/drivers; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: coremark_launcher.srec
  ILINK.IlinkOutputFile: coremark_launcher.out
  ILINK.IlinkIcfFile: ../../../cm4_loader/MIMXRT1176xxxxx_cm4_ocram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src
    ../../../cm4_loader/: cm4_coremark.h loader.c
  group src/startup
    ../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm4.s
    ../../../../../devices/MIMXRT1176/: system_MIMXRT1176_cm4.c system_MIMXRT1176_cm4.h
