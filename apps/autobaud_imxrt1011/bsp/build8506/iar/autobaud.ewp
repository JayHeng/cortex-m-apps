# IAR project autobaud.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: coremark.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 41
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1011DAE5A
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../src; ../../../src; ../../../../../devices/MIMXRT1011; ../../../../../devices/MIMXRT1011/drivers; ../../../../../devices/MIMXRT1011/utilities/str; ../../../../../devices/MIMXRT1011/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../components/autobaud; ../../../../../components/microseconds; ../../../../../CMSIS/Include
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: coremark.srec
  ILINK.IlinkOutputFile: autobaud.out
  ILINK.IlinkIcfFile: ../../../../../devices/MIMXRT1011/iar/MIMXRT1011xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group IMXRT1011/bsp
    ../../src/: app.h board.c board.h clock_config.c clock_config.h hardware_init.c pin_mux.c pin_mux.h pinmux_utility.c
  group src
    ../../../src/: main.c
  group src/component/autobaud
    ../../../../../components/autobaud/: autobaud.h autobaud_irq.c
  group src/component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group src/component/microseconds
    ../../../../../components/microseconds/: microseconds.h microseconds_common.c microseconds_cortexm_systick.c microseconds_imxrt_pit.c
  group src/component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group src/component/uart
    ../../../../../components/uart/: lpuart_adapter.c uart.h
  group src/platform/drivers
    ../../../../../devices/MIMXRT1011/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h
  group src/platform/utilities
    ../../../../../devices/MIMXRT1011/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT1011/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1011/utilities/str/: fsl_str.c fsl_str.h
  group src/startup
    ../../../../../devices/MIMXRT1011/iar/: startup_MIMXRT1011.s
    ../../../../../devices/MIMXRT1011/: system_MIMXRT1011.c system_MIMXRT1011.h
