# IAR project dhrystone_loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: coremark.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1176DVMAA_cm7
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../loader; ../../../../../devices/MIMXRT1176; ../../../../../devices/MIMXRT1176/drivers; ../../../../../CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: coremark.srec
  ILINK.IlinkOutputFile: dhrystone_loader.out
  ILINK.IlinkIcfFile: ../../../loader/MIMXRT1176xxxxx_cm7_ocram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src
    ../../../loader/: cm7_dhrystone.h loader.c
  group src/startup
    ../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
    ../../../../../devices/MIMXRT1176/: system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
