# IAR project coremark_core1.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT798S_M33_1 NXP MIMXRT798S_M33_1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT798SGFOA_cm33_core1; BOOT_HEADER_ENABLE=0; MCUXPRESSO_SDK; SERIAL_PORT_TYPE_UART=1; ITERATIONS=6000; COMPILER_VERSION="IAR EWARM v9.50.1"
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../src_core1; ../../../src; ../../../../../devices_v3/MIMXRT798S/drivers; ../../../../../devices_v3/MIMXRT798S; ../../../../../devices_v3/MIMXRT798S/utilities/str; ../../../../../devices_v3/MIMXRT798S/utilities/debug_console; ../../../../../components_v3/uart; ../../../../../components_v3/serial_manager; ../../../../../components_v3/lists; ../../../../../CMSIS/Include; ../../../../../middleware/coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: core1_image.bin
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000
  ILINK.IlinkIcfFile: ../../../../../devices_v3/MIMXRT798S/iar/MIMXRT798Sxxxx_cm33_core1_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT595S_M33 NXP MIMXRT595S_M33
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT595SFFOC_cm33; BOOT_HEADER_ENABLE=1; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK; ITERATIONS=20000; COMPILER_VERSION="IAR EWARM v9.50.1"
  ICCARM.CCIncludePath2: ../../src; ../../../src; ../../../../../devices_v2/MIMXRT595S/drivers; ../../../../../devices_v2/MIMXRT595S; ../../../../../devices_v2/MIMXRT595S/utilities/str; ../../../../../devices_v2/MIMXRT595S/utilities/debug_console; ../../../../../components_v2/uart; ../../../../../components_v2/serial_manager; ../../../../../components_v2/lists; ../../../../../CMSIS/Include; ../../../../../middleware/coremark
  AARM.ADefines: NDEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkIcfFile: ../../../../../devices_v2/MIMXRT595S/iar/MIMXRT595Sxxxx_cm33_ram.icf
  group board
    ../../src_core1/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    ../../../../../components_v3/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    ../../../../../components_v3/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    ../../../../../components_v3/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group coremark_bsp
    ../../../src/: core_portme.c cvt.c ee_printf.c
  group device
    ../../../../../devices_v3/MIMXRT798S/: fsl_device_registers.h MIMXRT798S_cm33_core1.h MIMXRT798S_cm33_core1_features.h system_MIMXRT798S_cm33_core1.c system_MIMXRT798S_cm33_core1.h
  group drivers
    ../../../../../devices_v3/MIMXRT798S/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_iopctl.h fsl_lpflexcomm.c fsl_lpflexcomm.h fsl_lpuart.c fsl_lpuart.h fsl_mrt.c fsl_mrt.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h
  group middleware/coremark
    ../../../../../middleware/coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group startup
    ../../../../../devices_v3/MIMXRT798S/iar/: startup_MIMXRT798S_cm33_core1.s
  group utilities
    ../../../../../devices_v3/MIMXRT798S/utilities/: fsl_assert.c
    ../../../../../devices_v3/MIMXRT798S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices_v3/MIMXRT798S/utilities/str/: fsl_str.c fsl_str.h
